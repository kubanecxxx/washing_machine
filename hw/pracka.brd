# Repository kubanecxxx/washing_machine

File README.md:

# washing_machine
Old automatic washing machine electronic controller

This is and old washing machine renovation. The main reason for this project is the old mechanical programmer got cracked and the price for a new one was almost price of a new washing machine.

The project page is hosted on hackaday.io: https://hackaday.io/project/19873-washing-machine-renovation

Machine itself
----
Washing machine type is <b>Ardo A900</b>. It has basic features like:
- two speed motor with 5uF condenser
- water filling valve
- water drain pump
- water heater
- front door electric lock
- low and high level water level switch
- temperature switch
- few front panel switches (most of them are not used any more)

Hardware part
-----

Schematics and board layout are drawed in Eagle version 6. I used STM32F100C6 micronctroller.

The reason for using triacs instead of relays was switching in zero crossing of sine voltage. I used relays in previous version of this project and I had a lot of problems with this. Relay contacts got welded, switching caused microcontroller unhandled exceptions etc.

With triacs there are no more problems with MCU unhandled exceptions. But the water heater triac dissipates almost 10Watts of heat. It means <b>huge heatsink</b> is needed.

Software part
----

Software is based on ChibiOS real time operating system for microntollers. I made [CMake fork](https://github.com/kubanecxxx/chibios_fork) of the ChibiOS - it is my repositories. You probably need to clone this repository to build this project or you can take the data from the [CMakeLists.txt](fw/CMakeLists.txt) and create a ChibiOS Makefile or just edit the CMakeLists (you will probably need to adjust path to the GCC toolchain and path to the ChibiOS directory) to build this project on you machine.

Development toolchain is GNU arm gcc (https://launchpadlibrarian.net/209776202/gcc-arm-none-eabi-4_9-2015q2-20150609-linux.tar.bz2) version 4.9 - it contains interesting newlib library which saves a lot of RAM and hardware floating point support and many other features.

You can flash the MCU via openocd or my [kstlink](https://github.com/kubanecxxx/kstlink) project which is simple gdb server to debug and flash STM microcontrollers (I feel openocd too heavy).

Firmware is not well documented yet.

## EAGLE design hw/pracka.brd

Parts:
D1, D2, D3, D4, D5, D6, D7: LED3MM; LED3MM@1
F1, F2, F3: SH22,5A
OK1, OK2, OK3, OK4, OK5, OK6, OK7: MOC3062; DIL06
R1, R3, R5, R7, R9, R11, R13: 2K7; R0805
R2, R4, R6, R8, R10, R12, R14: 470R; 0207/7
TR1, TR2, TR3, TR4, TR5, TR6, TR7: BT136*; TO220DS
X4: W237-03P; W237-133
X5: W237-02P; W237-132
X6: W237-3E

Connections:
GND: OK1.2 (K), OK2.2 (K), OK3.2 (K), OK4.2 (K), OK5.2 (K), OK6.2 (K), OK7.2 (K); also elsewhere on the board
HEAT: D4.A; also elsewhere on the board
LOCK: D7.A; also elsewhere on the board
L_HEAT: F2.1, TR4.A1; also elsewhere on the board
L_MOTOR: F1.1, TR1.A1, TR2.A1, TR3.A1; also elsewhere on the board
L_ZBYTEK: F3.1, TR5.A1, TR6.A1, TR7.A1; also elsewhere on the board
M1: D1.A; also elsewhere on the board
M2: D2.A; also elsewhere on the board
M3: D3.A; also elsewhere on the board
unnamed: OK1.1 (A), R1.2
unnamed: OK2.1 (A), R3.2
unnamed: OK2.4 (A1), TR2.G
unnamed: D1.K (C), R1.1
unnamed: D2.K (C), R3.1
unnamed: OK1.4 (A1), TR1.G
unnamed: OK2.6 (A2), R4.1
unnamed: OK3.1 (A), R5.2
unnamed: OK3.4 (A1), TR3.G
unnamed: D3.K (C), R5.1
unnamed: OK3.6 (A2), R6.1
unnamed: OK4.1 (A), R7.2
unnamed: OK4.4 (A1), TR4.G
unnamed: D4.K (C), R7.1
unnamed: OK4.6 (A2), R8.1
unnamed: OK5.1 (A), R9.2
unnamed: OK5.4 (A1), TR5.G
unnamed: D5.K (C), R9.1
unnamed: OK5.6 (A2), R10.1
unnamed: OK6.1 (A), R11.2
unnamed: OK6.4 (A1), TR6.G
unnamed: D6.K (C), R11.1
unnamed: OK6.6 (A2), R12.1
unnamed: OK7.1 (A), R13.2
unnamed: OK7.4 (A1), TR7.G
unnamed: D7.K (C), R13.1
unnamed: OK7.6 (A2), R14.1
unnamed: F1.2, F2.2, F3.2, X5.2
unnamed: OK1.6 (A2), R2.1
PUMP: D5.A; also elsewhere on the board
P_HEAT: R8.2, TR4.A2, X5.1
P_LOCK: R14.2, TR7.A2, X6.3
P_M1: R2.2, TR1.A2, X4.1
P_M2: R4.2, TR2.A2, X4.2
P_M3: R6.2, TR3.A2, X4.3
P_PUMP: R10.2, TR5.A2, X6.1
P_VALVE: R12.2, TR6.A2, X6.2
VALVE: D6.A; also elsewhere on the board

Notes on the sheet:
topeni
cerpadlo
ventil
zamek
outputs
SLOW motor
FAST motor

Parts:
C1, C3, C4, C5: 1M; E2,5-5
D8, D9, D10, D11: 1N4004; DO41-10
LED1, LED2, LED3, LED4: LED3MM
OK8, OK9, OK10, OK11: PC817; DIL04
R15, R16, R17, R18: 100K; 0207/7
X1: W237-02P; W237-132

Connections:
+3V3: OK8.4 (COL), OK9.4 (COL), OK10.4 (COL), OK11.4 (COL); also elsewhere on the board
DOOR_LOCKED: C5.+, OK11.3 (EMIT); also elsewhere on the board
FUSE_HEAT: C3.+, OK9.3 (EMIT); also elsewhere on the board
FUSE_MOTOR: C1.+, OK8.3 (EMIT); also elsewhere on the board
FUSE_ZBYTEK: C4.+, OK10.3 (EMIT); also elsewhere on the board
GND: C1.-, C3.-, C4.-, C5.-; also elsewhere on the board
L_DOOR_LOCKED: R18.1, X1.1
L_HEAT: R16.1; also elsewhere on the board
L_MOTOR: R15.1; also elsewhere on the board
L_ZBYTEK: R17.1; also elsewhere on the board
N: OK8.2 (C), OK9.2 (C), OK10.2 (C), OK11.2 (C), X1.2
unnamed: D8.A, R15.2
unnamed: D8.C, LED1.A
unnamed: LED1.K (C), OK8.1 (A)
unnamed: D9.A, R16.2
unnamed: D9.C, LED2.A
unnamed: LED2.K (C), OK9.1 (A)
unnamed: D10.A, R17.2
unnamed: D10.C, LED3.A
unnamed: LED3.K (C), OK10.1 (A)
unnamed: D11.A, R18.2
unnamed: D11.C, LED4.A
unnamed: LED4.K (C), OK11.1 (A)

Parts:
LED5, LED6, LED7, LED8: LED3MM
OK12, OK13, OK14, OK15: PC817; DIL04
R19, R20, R21, R22: 1K5; R0805
X2: W237-05P; W237-5P

Connections:
+3V3: OK12.4 (COL), OK13.4 (COL), OK14.4 (COL), OK15.4 (COL); also elsewhere on the board
+12V: X2.5; also elsewhere on the board
GND: OK12.2 (C), OK13.2 (C), OK14.2 (C), OK15.2 (C); also elsewhere on the board
HIGH_LEVEL: OK13.3 (EMIT); also elsewhere on the board
I_HIGH_LEVEL: R20.1, X2.2
I_LOW_LEVEL: R19.1, X2.1
I_NEZDIMAT: R22.1, X2.4
I_TEMPERATURE: R21.1, X2.3
LOW_LEVEL: OK12.3 (EMIT); also elsewhere on the board
unnamed: LED5.A, R19.2
unnamed: LED6.K (C), OK13.1 (A)
unnamed: LED5.K (C), OK12.1 (A)
unnamed: LED6.A, R20.2
unnamed: LED7.K (C), OK14.1 (A)
unnamed: LED7.A, R21.2
unnamed: LED8.K (C), OK15.1 (A)
unnamed: LED8.A, R22.2
NEZDIMAT: OK15.3 (EMIT); also elsewhere on the board
TEMPERATURE: OK14.3 (EMIT); also elsewhere on the board

Parts:
C16, C17, C18, C21: 100n; C1206
IC4: STM32F10XCXT6; TQFP48
R23, R25, R26, R27: 10K; R0805
R24: 0R; R0805
SL1, SL3, SL4: M04; 04P
SL2: M02; 02P

Connections:
+3V3: C16.1, C17.1, C18.1, C21.1, IC4.9 (VDDA), IC4.24 (VDD_1), IC4.36 (VDD_2), IC4.48 (VDD_3), R24.2, R25.2, SL1.4, SL4.1; also elsewhere on the board
+5V: R26.2, R27.2, SL3.4; also elsewhere on the board
DOOR_LOCKED: IC4.13 (PA3); also elsewhere on the board
ENC_SWITCH: IC4.12 (PA2), SL4.2
FUSE_HEAT: IC4.16 (PA6); also elsewhere on the board
FUSE_MOTOR: IC4.15 (PA5); also elsewhere on the board
FUSE_ZBYTEK: IC4.14 (PA4); also elsewhere on the board
GND: C16.2, C17.2, C18.2, C21.2, IC4.8 (VSSA), IC4.23 (VSS_1), IC4.35 (VSS_2), IC4.47 (VSS_3), R23.2, SL1.1, SL2.1, SL3.1; also elsewhere on the board
HEAT: IC4.25 (PB12); also elsewhere on the board
HIGH_LEVEL: IC4.27 (PB14); also elsewhere on the board
I2C1_SCL: IC4.45 (PB8), R27.1, SL3.3
I2C1_SDA: IC4.46 (PB9), R26.1, SL3.2
LOCK: IC4.17 (PA7); also elsewhere on the board
LOW_LEVEL: IC4.26 (PB13); also elsewhere on the board
M1: IC4.22 (PB11); also elsewhere on the board
M2: IC4.21 (PB10); also elsewhere on the board
M3: IC4.20 (PB2); also elsewhere on the board
unnamed: IC4.44 (BOOT0), R23.1, R24.1
unnamed: IC4.1 (VBAT), SL2.2
NEZDIMAT: IC4.29 (PA8); also elsewhere on the board
NRST: IC4.7 (NRST), R25.1
PUMP: IC4.19 (PB1); also elsewhere on the board
SWDCLK: IC4.37 (PA14), SL1.2
SWDIO: IC4.34 (PA13), SL1.3
TEMPERATURE: IC4.28 (PB15); also elsewhere on the board
TIM2_CH1: IC4.10 (PA0), SL4.4
TIM2_CH2: IC4.11 (PA1), SL4.3
VALVE: IC4.18 (PB0); also elsewhere on the board

Notes on the sheet:
SWD
REMAP
Encoder
DISABLE JTAG

Parts:
C2, C23: CPOL-EUE2.5-7; E2,5-7
C6, C7, C9, C10: 100n; C1206
D12, D13: DIODE-SMC; SMC
IC1: 78L05Z; TO92
U$1: LF33; DPACK
X3: W237-02P; W237-132

Connections:
+3V3: C10.1, C23.+, D13.C, U$1.3 (OUT); also elsewhere on the board
+5V: C7.1, IC1.1 (VO); also elsewhere on the board
+12V: C2.+, C6.1, C9.1, D12.C, IC1.3 (VI), U$1.1 (IN), X3.1; also elsewhere on the board
GND: C2.-, C6.2, C7.2, C9.2, C10.2, C23.-, D12.A, D13.A, IC1.2 (GND), U$1.2 (GND), X3.2; also elsewhere on the board

Board: 2 copper layers, 109.2 x 86.0 mm, 100 parts (39 on the bottom side), 94 nets.

## Code that names these connections

File fw/relays.c:

#include "relays.h"
#include "ch.h"
#include "hal.h"
#include "inputs.h"

 const  port_t relays[RELAY_COUNT] = {
    {GPIOA, 7},  // lock
    {GPIOB, 0},  // valve
    {GPIOB, 1}, // pump
    {GPIOB, 2}, // m3
    {GPIOB, 10}, // m2
    {GPIOB, 11}, // m1
    {GPIOB, 12}, // heat
};

relay_status_t outputs;
relay_status_t outputs_forced;

static void incompatible(void);

void user_unhandled_exception(void)
{
    //disable all outputs in case of failure
    outputs.status  = 0;
    relay_writeall();

    asm("bkpt");
}

static void relay_write(uint8_t number, uint8_t enable);

void relay_write(uint8_t number, uint8_t enabled) {
  if (enabled) {

    palSetPad(relays[number].port, relays[number].pin);
  } else {
    palClearPad(relays[number].port, relays[number].pin);
  }
}

void relay_stop_motor(void)
{
    incompatible();
}

void relay_start_motor(direction_t dir, speed_t speed)
{
    relay_stop_motor();

    if (speed == LOW_SPEED)
    {
        if (dir == LEFT)
        {
            outputs.u.motor_slow_l = 1;
        }
        else if (dir == RIGHT)
        {
            outputs.u.motor_slow_r = 1;
        }
    }
    else if (speed == HIGH_SPEED)
    {
        outputs.u.motor_fast = 1;
    }
}

void incompatible(void)
{
    outputs.u.motor_fast = 0;
    outputs.u.motor_slow_l =  0;
    outputs.u.motor_slow_r =  0;
}

void relay_writeall()
{
    uint8_t i;
    //check incompatible outputs    
    uint8_t a;
    a = outputs.u.motor_fast + outputs.u.motor_slow_l + outputs.u.motor_slow_r;
    if (a > 1)
    {
        //wrong
        //alarm
        incompatible();        
    }   

    uint8_t v,h;
    v = outputs.u.valve;
    h = outputs.u.heater;
    /*
    outputs.u.heater = outputs.u.heater && inputs.b.low_level &&
            !inputs.b.temperature;
    outputs.u.valve = outputs.u.valve && !inputs.b.high_level;
    */

    for (i = 0; i < RELAY_COUNT; i++) {   

      relay_write(i, (((outputs.status >> i) & 1) || ((outputs_forced.status >> i)) & 1));
    }

    outputs.u.valve = v;
    outputs.u.heater = h;
}

void relay_init(void) {
  uint8_t i;
  const port_t *p = relays;

  for (i = 0; i < RELAY_COUNT; i++) {
    palSetPadMode(p->port, p->pin, PAL_MODE_OUTPUT_PUSHPULL);
    palClearPad(p->port, p->pin);

    p++;
  }
}

File fw/inputs.c:

#include "ch.h"
#include "hal.h"
#include "inputs.h"

typedef struct
{
    GPIO_TypeDef * port;
    uint8_t pin;
} gpio_t;

static const gpio_t _inputs[INPUT_NUMBER] =
{
    {GPIOA, 3}, //door locked
    {GPIOA, 4}, //fuse zbytek
    {GPIOA, 5}, //fuse motor
    {GPIOA, 6}, //fuse heat
    {GPIOB, 13}, //low level
    {GPIOB, 14}, //high level
    {GPIOB, 15}, //temperature
    {GPIOA, 8},  //nezdimat
    {GPIOA, 2} //enkoder switch
};

inputs_t inputs;
uint8_t w, v;

void inputs_read(void)
{
    static uint8_t old[INPUT_NUMBER];
    uint8_t temp;
    uint8_t i ;
    for (i = 0 ; i < INPUT_NUMBER ; i++)
    {
        temp = palReadPad(_inputs[i].port, _inputs[i].pin);

        if (old[i] == temp)
        {
            inputs.w &= ~(1<<i);
            if (temp)
                inputs.w |= (1<<i);
        }

        old[i] = temp;

    }

    inputs.b.nezdimat = !inputs.b.nezdimat;
    inputs.b.temperature = inputs.b.temperature || inputs.b.nezdimat;
    inputs.b.nezdimat = 0;

    inputs.b.door =  1;

}

void inputs_init(void)
{
    RCC->APB2ENR |= RCC_APB2ENR_AFIOEN;
    AFIO->MAPR |= AFIO_MAPR_SWJ_CFG_JTAGDISABLE;
    uint8_t i;
    for (i = 0; i < INPUT_NUMBER; i++)
        palSetPadMode(_inputs[i].port, _inputs[i].pin, PAL_MODE_INPUT_PULLDOWN);

}

## Commit log

2017-02-11 cmake modify
2017-02-12 added manual menu, notebook dead - backup
2017-02-12 small statemachine fixes, added display message - number of rinsing and spinning
2017-02-12 hardware fixes
2017-02-14 added watchdog to main file
    some time constants changed it the statemachine
    added feature to gui - current counter / counter preset
2017-02-18 Fixes #4
    Added startup screen when watchdog fails
2017-02-19 Fixes #4 - now really
2017-03-16 added new function - only spinning state machine switch from slow to high speed because of motor is too weak
